# Keil uVision project driverlib-cm4f.uvproj, settings and files
target driverlib-cm4f (ARM-ADS)
  device: LM4F110B2QR Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: driverlib-cm4f (library)
  AfterMake: cmd.exe /C copy "!L" "..\%L"
  c flags: Optim=3 oTime=1 OneElfS=1 wLevel=2
  c define: rvmdk
  c include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Source
    ./: adc.c can.c comp.c cpu.c eeprom.c epi.c ethernet.c fan.c flash.c fpu.c gpio.c hibernate.c i2c.c i2s.c interrupt.c lpc.c mpu.c peci.c pwm.c qei.c ssi.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group Documentation
    ./: readme.txt
