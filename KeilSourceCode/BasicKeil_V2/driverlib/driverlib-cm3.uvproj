# Keil uVision project driverlib-cm3.uvproj, settings and files
target driverlib-cm3 (ARM-ADS)
  device: LM3S101 Texas Instruments
  cpu: IRAM(0x20000000-0x200007FF) IROM(0-0x1FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: driverlib-cm3 (library)
  AfterMake: cmd.exe /C copy "!L" "..\%L"
  c flags: Optim=3 oTime=1 OneElfS=1 wLevel=2
  c define: rvmdk
  c include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x800
  group Source
    ./: adc.c can.c comp.c cpu.c eeprom.c epi.c ethernet.c fan.c flash.c fpu.c gpio.c hibernate.c i2c.c i2s.c interrupt.c lpc.c mpu.c peci.c pwm.c qei.c ssi.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group Documentation
    ./: readme.txt
