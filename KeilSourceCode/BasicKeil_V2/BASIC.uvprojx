# Keil uVision project BASIC.uvprojx, settings and files
target BASIC (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BASIC
  AfterMake: fromelf --bin --output .\rvmdk\blinky.bin .\rvmdk\blinky.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA1
  c misc: --c99
  c include: E:\EmbeddedProject\Luminary
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\rvmdk\BASIC.sct
  link misc: --entry Reset_Handler
  group Source
    ./: main.c UART.c LED.c
  group Libraries
    E:/EmbeddedProject/Luminary/: driverlib-cm4f.lib
  group Documentation
    ./: readme.txt
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
